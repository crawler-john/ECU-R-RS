# Keil uVision project ECU_RS.uvproj, settings and files
target ECU_RS (ARM-ADS)
  device: STM32F101C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ECU_RS +hex
  c flags: OneElfS=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport;..\drivers\EEPROM;..\drivers\KEY;..\drivers\LED;..\drivers\SYSTEM\delay;..\drivers\SYSTEM\usart;..\drivers\SYSTEM\sys;..\DEBUG;..\drivers\CMT2300;..\drivers\TIMER;..\application\FILE;..\application\APPComm;..\application\RFM300H;..\application;..\application\USART1Comm;..\application\EVENT;..\application\Inverter;..\drivers\Watchdog
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application
    ../application/: main.c
  group STM32_stdperiph
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_tim.c stm32f10x_iwdg.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Drivers
    ../drivers/EEPROM/: Flash_24L512.c
    ../drivers/KEY/: key.c
    ../drivers/LED/: led.c
    ../drivers/SYSTEM/delay/: delay.c
    ../drivers/SYSTEM/usart/: usart.c
    ../drivers/SYSTEM/sys/: sys.c
    ../drivers/CMT2300/: CMT2300.c
    ../drivers/TIMER/: timer.c
    ../drivers/Watchdog/: watchdog.c
  group Debug
    ../DEBUG/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group FILE
    ../application/FILE/: file.c
  group APP
    ../application/APPComm/: appcomm.c
  group RFM300H
    ../application/RFM300H/: RFM300H.c
  group USART1Comm
    ../application/USART1Comm/: USART1Comm.c
  group EVENT
    ../application/EVENT/: event.c
  group Inverter
    ../application/Inverter/: inverter.c
